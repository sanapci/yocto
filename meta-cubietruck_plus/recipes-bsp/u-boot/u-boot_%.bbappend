FILESEXTRAPATHS:prepend:sunxi := "${THISDIR}/${PN}:"